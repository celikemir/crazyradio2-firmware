## boards/xiao_ble.conf
```kconfig
CONFIG_BOARD_SERIAL_BACKEND_CDC_ACM=n
CONFIG_USB_CDC_ACM=n
CONFIG_TARGET_UF2_BOOTLOADER=n
CONFIG_BUILD_OUTPUT_UF2=y
```
